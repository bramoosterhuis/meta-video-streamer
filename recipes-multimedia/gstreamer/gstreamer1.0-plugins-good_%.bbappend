SRC_URI += "file://link-to-vshostif.patch"
